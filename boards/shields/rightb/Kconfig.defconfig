## boards/shields/rightb/Kconfig.defconfig
```kconfig
if SHIELD_RIGHTB

config ZMK_KEYBOARD_NAME
    default "RightB"

config SPI
    default y

endif # SHIELD_RIGHTB
```
